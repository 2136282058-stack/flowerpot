# Keil uVision project stdLibPro.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stdLibPro
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\core;..\user;..\stm32f10x_fwlib\inc;..\system\inc;..\FreeRTOS\inc;..\FreeRTOS\port;..\hardware;..\APP;..\system;..\LCD_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c system.c
    ../FreeRTOS/inc/: FreeRTOSConfig.h
  group core
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group stm32f10x_fwlib
    ../stm32f10x_fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/port/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group Hardware
    ../hardware/: adc.c ds18b20.c gpio.c key.c motor_timer.c sgp30.c syn6288_time.c syn6288_uart.c
  group System
    ../system/: sys.c usart.c delay.c
  group APP
    ../APP/: Control_Task.c Display_Task.c Key_function.c Sensor_Task.c uart_Task.c keyControl_Task.c BluetoothDisplay_Task.c Voice_Task.c
  group LCD_APP
    ../LCD_APP/: GUI.c Lcd_Driver.c
